# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105xC ST STM32F105xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_STM32100B_EVAL; STM32F10X_CL
  ICCARM.CCIncludePath2: ; ..\; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\src; ..\..\..\Project/Common; ..\..\..\Project/TW8836; ..\..\..\Project/CAN; ..\..\..\Project/FM; ..\..\..\Project/ARM; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group ARM
    ../../ARM/: arm.c arm_driver.c
  group CANBUS
    ../../CAN/: can_config.h canbus.c canbus.h
  group Common
    ../../Common/: com.c compile.h GPS.c GPS.h i2c_driver.c libr.c libr.h MTN5.c MTN5.h System_Config.c system_function.c system_function.h touch.c touch.h type.h uart_fun.c
  group FM
    ../../FM/: radiofm.c
  group Libraries/CMSIS
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
  group Libraries/STM32F10x_StdPeriph_Driver/inc
    ../../../Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_conf.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Libraries/STM32F10x_StdPeriph_Driver/src
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group project
    ../: main.c stm32f10x_it.c
  group TW8836
    ../../TW8836/: FOSD.c menu.c pannel.c pannel.h pannel_includ.h pnl_hannstar_9.h SPIFlash.c SPIOSD.c TW8836.c Tw8836_const.h tw8836_func.c Tw8836_func.h
