# IAR project IAP_Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105RC ST STM32F105RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_CL; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ; $TOOLKIT_DIR$\CMSIS\Include; ..\SOFTWARE\APP; ..\SOFTWARE\CMSIS; ..\SOFTWARE\CMSIS\IAR_Startup; ..\SOFTWARE\BSP; ..\SOFTWARE\Startup; ..\SOFTWARE\FWLib; ..\SOFTWARE\FWLib\LIB; ..\SOFTWARE\FWLib\INC
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IAP_Project.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: Project.icf
  ILINK.IlinkAdditionalLibs: ..\SOFTWARE\APP\aes_decode_lib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: c.srec
  group APP
    ../SOFTWARE/APP/: benze_canbus.c common.c download.c i2c_driver.c main.c pannel.c stm32f10x_it.c ymodem.c
  group BSP
    ../SOFTWARE/BSP/: bsp.c BspTime2.c BspTime3.c IAPUsart.c
  group CMSIS
    ../SOFTWARE/CMSIS/IAR_Startup/: startup_stm32f10x_cl.s
    ../SOFTWARE/CMSIS/: system_stm32f10x.c
  group Doc
    ../Doc/: note.txt
  group FWLib
    ../SOFTWARE/FWLib/LIB/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
