# Keil uVision project Project.uvproj, settings and files
target Project (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Project
  AfterMake: fromelf.exe --bin -o./output/Project.bin ./Obj/Project.axf
  AfterMake: fromelf.exe --i32 -o./output/Project.hex ./Obj/Project.axf
  c flags: Optim=1
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER,keil
  c include: ..\SOFTWARE\APP;..\SOFTWARE\BSP;..\SOFTWARE\Driver;..\SOFTWARE\FWLib\INC;..\SOFTWARE\CMSIS;..\SOFTWARE\CMSIS\MDK_Startup
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../SOFTWARE/CMSIS/MDK_Startup/: startup_stm32f10x_cl.s
  group APP
    ../SOFTWARE/APP/: main.c common.c download.c ymodem.c stm32f10x_it.c i2c_driver.c pannel.c
  group BSP
    ../SOFTWARE/BSP/: bsp.c BspTime2.c BspTime3.c IAPUsart.c
  group CMSIS
    ../SOFTWARE/CMSIS/: system_stm32f10x.c
  group FWLIB
    ../SOFTWARE/FWLib/LIB/: stm32f10x_can.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c cortexm3_macro.s misc.c
  group DOC
    ../Doc/: note.txt
